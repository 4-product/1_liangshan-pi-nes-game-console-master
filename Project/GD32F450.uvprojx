# Keil uVision project GD32F450.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware\usart0;..\Hardware\LED;..\Hardware\key;..\Hardware\beep;..\Hardware\adc_key;..\Hardware\eeprom;..\Hardware\IIC;..\Hardware\SPI;..\Hardware\LCD;..\Hardware\TaskTimer;..\Hardware\w25q;..\Hardware\dac_audio;..\Hardware\SDRAM;..\Hardware\FSMC8080;..\NES;..\NES\Game;..\MALLOC;..\Hardware\Dac;..\CW_QUEUE;..\Hardware\SDIO;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\Hardware\motor;..\Hardware\rtc;..\Hardware\adc_bat;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x300000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c image.h flash_nes.h
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_adc.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_exti.c gd32f4xx_crc.c gd32f4xx_misc.c gd32f4xx_dac.c gd32f4xx_exmc.c gd32f4xx_sdio.c gd32f4xx_dma.c gd32f4xx_rtc.c gd32f4xx_pmu.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group HARDWARE
    ../Hardware/usart0/: usart0.c
    ../Hardware/key/: key.c
    ../Hardware/LED/: led.c
    ../Hardware/beep/: beep.c
    ../Hardware/SPI/: spi.c
    ../Hardware/TaskTimer/: taskTimer.c
    ../Hardware/adc_key/: adc_Key.c
    ../Hardware/w25q/: w25qxx.c
    ../Hardware/dac_audio/: dac_audio.c
    ../Hardware/SDRAM/: exmc_sdram.c
    ../Hardware/LCD/: lcd.c lcd_init.c
    ../Hardware/Dac/: Dac.c DacAudio.c
    ../Hardware/SDIO/: sdcard.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/eeprom/: eeprom.c
    ../Hardware/motor/: bsp_pwm.c
    ../Hardware/rtc/: rtc.c
    ../Hardware/adc_bat/: adc_bat.c
  group Nes
    ../NES/: nes_apu.c nes_crc32.c nes_main.c nes_mapper.c nes_ppu.c 6502.s cart.s
  group Malloc
    ../MALLOC/: malloc.c
  group Queue
    ../CW_QUEUE/: cw_queue.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
  group TEXT
    ../TEXT/: text.c fontupd.c
  group APP
    ../APP/: fat_app.c ui_app.c
